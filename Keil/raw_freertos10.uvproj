# Keil uVision project raw_freertos10.uvproj, settings and files
target PROJECT (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: raw_freertos10 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=4 v6LangP=4 wLevel=2
  c define: STM32F10X_CL,USE_STDPERIPH_DRIVER,FreeRTOS
  c include: ..\STM32F10x_FWLib\inc;..\APP;..\CORE;..\FREERTOS\include;..\FREERTOS\portable\RVDS\ARM_CM3;..\BSP\usart;..\BSP\timer;..\BSP\spi;..\BSP\flash;..\BSP\LAN;..\SX12xxDrivers-V2.1.0\src\radio;..\Tracealyzer\include;..\Tracealyzer\config;..\Tracealyzer\streamports\Jlink_RTT\include;..\W5500_Lib\Ethernet;..\W5500_Lib\Ethernet\W5500;..\W5500_Lib\Internet\DHCP;..\W5500_Lib\Internet\httpServer;..\W5500_Lib\Internet\DNS;..\W5500_Lib\Internet\MQTT\MQTTPacket\src;..\W5500_Lib\Internet\MQTT;..\BSP\DHT11;..\modbus\include;..\modbus\tcp;..\modbus\ascii;..\modbus\rtu;..\modbus\port;..\CJASON;..\BSP\ESP8266COM;..\BSP\i2c
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ../APP/: app_tsks.c main.c globals.c cmd_server.c
  group CORE
    ../CORE/: core_cm3.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_cl.s
  group FREERTOS
    ../FREERTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FREERTOS/portable/RVDS/ARM_CM3/: port.c
    ../FREERTOS/portable/MemMang/: heap_4.c
  group STM32F10x_FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_crc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_rcc.c
  group BSP/MCU
    ../BSP/usart/: usart.c
    ../BSP/timer/: timer.c
    ../BSP/spi/: spi.c
    ../BSP/flash/: flash.c
    ../BSP/LAN/: w5500interface.c
    ../BSP/DHT11/: dht11_driver.c
    ../BSP/modbus/: freemodbus_interface.c
    ../BSP/ESP8266COM/: esp_interface.c
    ../BSP/i2c/: i2c.c
  group Sx1278Driver
    ../SX12xxDrivers-V2.1.0/src/radio/: sx1276-Hal.c sx1276-LoRa.c sx1276-LoRaMisc.c sx1276.c
  group Tracealyzer
    ../Tracealyzer/: trcKernelPort.c trcSnapshotRecorder.c trcStreamingRecorder.c
    ../Tracealyzer/streamports/Jlink_RTT/: SEGGER_RTT.c trcStreamingPort.c
  group W5500/ETHERNET
    ../W5500_Lib/Ethernet/: wizchip_conf.c socket.c
    ../W5500_Lib/Ethernet/W5500/: w5500.c
  group W5500/INTERNET
    ../W5500_Lib/Internet/DHCP/: dhcp.c
    ../W5500_Lib/Internet/DNS/: dns.c
  group MQTT
    ../W5500_Lib/Internet/MQTT/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
    ../W5500_Lib/Internet/MQTT/: transport.c
  group MODBUS_SLAVE
    ../modbus/: mb.c
    ../modbus/tcp/: mbtcp.c
    ../modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../modbus/ascii/: mbascii.c
    ../modbus/rtu/: mbcrc.c mbrtu.c
    ../modbus/port/: portevent.c porttimer.c portserial.c
  group CJASON
    ../CJASON/: cJSON.c
